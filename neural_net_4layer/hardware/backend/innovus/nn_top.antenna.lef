

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO nn_top 
  PIN clk 
    ANTENNAPARTIALMETALAREA 6.63075 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.523 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.2744 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3328 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04125 LAYER metal4 ; 
    ANTENNAMAXAREACAR 15.7903 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 69.2291 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.831515 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal5 ;
    ANTENNAGATEAREA 0.04125 LAYER metal5 ; 
    ANTENNAMAXAREACAR 16.2655 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 73.0303 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 18.5416 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 74.3232 LAYER metal6 ;
    ANTENNAGATEAREA 0.12375 LAYER metal6 ; 
    ANTENNAMAXAREACAR 166.097 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 673.622 LAYER metal6 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER via6 ;
  END clk
  PIN reset 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1045 LAYER metal3 ; 
    ANTENNAMAXAREACAR 2.40813 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 9.19522 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.0937799 LAYER via3 ;
  END reset
  PIN wr_en 
    ANTENNAPARTIALMETALAREA 0.90755 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6302 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 5.5468 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.2656 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 22.834 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 91.4144 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal6 ; 
    ANTENNAMAXAREACAR 882.63 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 3535.32 LAYER metal6 ;
    ANTENNAMAXCUTCAR 1.03158 LAYER via6 ;
  END wr_en
  PIN din[15] 
    ANTENNAPARTIALMETALAREA 8.9558 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.1564 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.86325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 24.9294 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 99.366 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.746667 LAYER via3 ;
  END din[15]
  PIN din[14] 
    ANTENNAPARTIALMETALAREA 0.12355 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4942 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.3332 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4112 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 2.0188 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1536 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.05225 LAYER metal6 ; 
    ANTENNAMAXAREACAR 75.3321 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 305.833 LAYER metal6 ;
    ANTENNAMAXCUTCAR 1.03158 LAYER via6 ;
  END din[14]
  PIN din[13] 
    ANTENNAPARTIALMETALAREA 11.6512 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.8398 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4795 LAYER metal3 ; 
    ANTENNAMAXAREACAR 35.0885 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 140.798 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.570219 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAGATEAREA 0.4795 LAYER metal4 ; 
    ANTENNAMAXAREACAR 35.1293 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 141.125 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.611095 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.2156 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9408 LAYER metal5 ;
    ANTENNAGATEAREA 0.4795 LAYER metal5 ; 
    ANTENNAMAXAREACAR 35.579 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 143.087 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAMAXCUTCAR 0.651971 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 5.6448 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 22.736 LAYER metal6 ;
    ANTENNAGATEAREA 0.76475 LAYER metal6 ; 
    ANTENNAMAXAREACAR 42.9602 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 172.817 LAYER metal6 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER via6 ;
  END din[13]
  PIN din[12] 
    ANTENNAPARTIALMETALAREA 7.96495 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.0558 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7495 LAYER metal3 ; 
    ANTENNAMAXAREACAR 28.1139 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 111.979 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.42765 LAYER via3 ;
  END din[12]
  PIN din[11] 
    ANTENNAPARTIALMETALAREA 1.98765 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9702 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 22.711 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 90.7047 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END din[11]
  PIN din[10] 
    ANTENNAPARTIALMETALAREA 7.80255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4258 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.58175 LAYER metal3 ; 
    ANTENNAMAXAREACAR 28.8453 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 115.706 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.56 LAYER via3 ;
  END din[10]
  PIN din[9] 
    ANTENNAPARTIALMETALAREA 0.29995 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1998 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 2.6852 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8192 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 11.1524 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 44.688 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1285 LAYER metal6 ; 
    ANTENNAMAXAREACAR 120.871 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 484.935 LAYER metal6 ;
    ANTENNAMAXCUTCAR 0.699554 LAYER via6 ;
  END din[9]
  PIN din[8] 
    ANTENNAPARTIALMETALAREA 10.1867 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.1782 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.00025 LAYER metal3 ; 
    ANTENNAMAXAREACAR 34.8109 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 139.362 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via3 ;
  END din[8]
  PIN din[7] 
    ANTENNAPARTIALMETALAREA 0.33915 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3566 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.4508 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8816 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 2.5676 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3488 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2505 LAYER metal6 ; 
    ANTENNAMAXAREACAR 31.6952 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 128.143 LAYER metal6 ;
    ANTENNAMAXCUTCAR 0.599069 LAYER via6 ;
  END din[7]
  PIN din[6] 
    ANTENNAPARTIALMETALAREA 0.24115 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9646 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 2.7244 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 10.976 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3265 LAYER metal6 ; 
    ANTENNAMAXAREACAR 30.1899 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 121.748 LAYER metal6 ;
    ANTENNAMAXCUTCAR 0.61022 LAYER via6 ;
  END din[6]
  PIN din[5] 
    ANTENNAPARTIALMETALAREA 4.9168 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.8436 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4795 LAYER metal3 ; 
    ANTENNAMAXAREACAR 40.454 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 161.872 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.756886 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAGATEAREA 0.4795 LAYER metal4 ; 
    ANTENNAMAXAREACAR 40.4949 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 162.199 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.797762 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 2.6852 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8192 LAYER metal5 ;
    ANTENNAGATEAREA 0.53175 LAYER metal5 ; 
    ANTENNAMAXAREACAR 45.5446 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 182.545 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.797762 LAYER via5 ;
  END din[5]
  PIN din[4] 
    ANTENNAPARTIALMETALAREA 0.63105 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.583 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.93175 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.4461 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 29.2591 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END din[4]
  PIN din[3] 
    ANTENNAPARTIALMETALAREA 0.10395 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4158 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 8.1732 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 32.7712 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04125 LAYER metal6 ; 
    ANTENNAMAXAREACAR 253.561 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1020.33 LAYER metal6 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER via6 ;
  END din[3]
  PIN din[2] 
    ANTENNAPARTIALMETALAREA 0.1253 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5012 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.098 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNAPARTIALMETALAREA 10.5056 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 42.1792 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.64275 LAYER metal6 ; 
    ANTENNAMAXAREACAR 48.3912 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 194.179 LAYER metal6 ;
    ANTENNAMAXCUTCAR 0.690533 LAYER via6 ;
  END din[2]
  PIN din[1] 
    ANTENNAPARTIALMETALAREA 11.725 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.194 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7385 LAYER metal3 ; 
    ANTENNAMAXAREACAR 33.1168 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 132.553 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.746667 LAYER via3 ;
  END din[1]
  PIN din[0] 
    ANTENNAPARTIALMETALAREA 3.85525 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.519 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28525 LAYER metal3 ; 
    ANTENNAMAXAREACAR 23.288 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 93.4495 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END din[0]
  PIN in_full 
    ANTENNAPARTIALMETALAREA 0.09345 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3738 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 3.3124 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.328 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.1155 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 10.094 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 40.9248 LAYER metal6 ;
  END in_full
  PIN inference_done 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.13965 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5586 LAYER metal3 ;
  END inference_done
  PIN predicted_class[3] 
    ANTENNAPARTIALMETALAREA 1.76925 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0966 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 1.1172 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5472 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.1164 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.544 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 213.366 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 864.853 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.24 LAYER via6 ;
  END predicted_class[3]
  PIN predicted_class[2] 
    ANTENNAPARTIALMETALAREA 0.25025 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.001 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 1.7836 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2128 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.9788 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9936 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 167.792 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 682.56 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END predicted_class[2]
  PIN predicted_class[1] 
    ANTENNAPARTIALMETALAREA 0.09345 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3738 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 4.9588 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.9136 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.8412 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4432 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 302.179 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1219.36 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END predicted_class[1]
  PIN predicted_class[0] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7623 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0884 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal3 ; 
    ANTENNAMAXAREACAR 30.7524 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 125.44 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END predicted_class[0]
  PIN max_score[15] 
    ANTENNAPARTIALMETALAREA 0.29155 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1858 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.41 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.7184 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 184.672 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 749.333 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[15]
  PIN max_score[14] 
    ANTENNAPARTIALMETALAREA 0.47565 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9026 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 2.5284 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.192 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.5472 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3456 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 253.899 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1029.23 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[14]
  PIN max_score[13] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.42875 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7346 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.0457 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 73.8667 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END max_score[13]
  PIN max_score[12] 
    ANTENNAPARTIALMETALAREA 0.11305 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4522 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.1372 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6272 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.0964 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 16.464 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 264.566 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1069.65 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[12]
  PIN max_score[11] 
    ANTENNAPARTIALMETALAREA 2.12835 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5526 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.6076 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5088 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 2.9596 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9168 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 202.752 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 822.4 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.24 LAYER via6 ;
  END max_score[11]
  PIN max_score[10] 
    ANTENNAPARTIALMETALAREA 0.09345 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3738 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 4.3708 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.5616 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.1164 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.544 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 239.886 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 970.933 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.24 LAYER via6 ;
  END max_score[10]
  PIN max_score[9] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.59465 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3982 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal3 ; 
    ANTENNAMAXAREACAR 24.3657 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 99.1467 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END max_score[9]
  PIN max_score[8] 
    ANTENNAPARTIALMETALAREA 0.11305 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4522 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 5.1156 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.5408 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.4492 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8752 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 294.619 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1189.12 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[8]
  PIN max_score[7] 
    ANTENNAPARTIALMETALAREA 2.02475 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1382 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.098 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.7828 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2096 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 247.099 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 999.787 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.24 LAYER via6 ;
  END max_score[7]
  PIN max_score[6] 
    ANTENNAPARTIALMETALAREA 2.25925 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0566 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.822 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3664 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 272.726 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 1101.55 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[6]
  PIN max_score[5] 
    ANTENNAPARTIALMETALAREA 0.09345 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3738 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 1.862 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5264 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 2.0972 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4672 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 94.779 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 390.507 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[5]
  PIN max_score[4] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.08955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3974 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal3 ; 
    ANTENNAMAXAREACAR 43.5924 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 176.8 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END max_score[4]
  PIN max_score[3] 
    ANTENNAPARTIALMETALAREA 0.11305 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4522 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.5684 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.352 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.0772 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3872 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 137.152 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 559.253 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[3]
  PIN max_score[2] 
    ANTENNAPARTIALMETALAREA 0.66185 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6474 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 2.5284 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.192 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 4.116 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6208 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 199.232 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 812.053 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.24 LAYER via6 ;
  END max_score[2]
  PIN max_score[1] 
    ANTENNAPARTIALMETALAREA 0.11305 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4522 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 1.078 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3904 LAYER metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via5 ;
    ANTENNADIFFAREA 0.109725 LAYER metal6 ; 
    ANTENNAPARTIALMETALAREA 3.9788 LAYER metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1504 LAYER metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal6 ; 
    ANTENNAMAXAREACAR 165.819 LAYER metal6 ;
    ANTENNAMAXSIDEAREACAR 679.893 LAYER metal6 ;
    ANTENNAMAXCUTCAR 2.05333 LAYER via6 ;
  END max_score[1]
  PIN max_score[0] 
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.83755 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3894 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02625 LAYER metal3 ; 
    ANTENNAMAXAREACAR 33.619 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 136.907 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via3 ;
  END max_score[0]
END nn_top

END LIBRARY
